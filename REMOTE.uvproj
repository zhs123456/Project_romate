# Keil uVision project REMOTE.uvproj, settings and files
target REMOTE (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: REMOTE +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\HARDWARE\sys;.\STM32_FWLIB\inc;.\WORK\capture;.\WORK\LCD;.\WORK\remote;.\WORK\time;.\WORK\usart;.\WORK\delay
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ./CORE/: startup_stm32f10x_hd.s core_cm3.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ./HARDWARE/sys/: sys.c
  group FWLIB
    ./STM32_FWLIB/src/: misc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group WORK
    ./WORK/capture/: capture.c
    ./WORK/LCD/: lcd.c
    ./WORK/time/: time.c
    ./WORK/usart/: usart.c
    ./WORK/delay/: delay.c
    ./WORK/remote/: remote.c
